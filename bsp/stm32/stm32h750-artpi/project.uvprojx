# Keil uVision project project.uvprojx, settings and files
target rt-thread (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32H750IBKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32H750xx, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_HAL_DRIVER
  c include: ..\..\..\components\dfs\dfs_v1\filesystems\devfs;packages\EasyFlash-v4.1.0\inc;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\spi;board\port;.;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\config;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\fal\inc;..\..\..\libcpu\arm\cortex-m7;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;applications;..\..\..\components\finsh;packages\rs485-latest\inc;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\stdio;packages\EasyLogger-v2.0.0\inc;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;packages\EasyLogger-v2.0.0\plugins\flash;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;board;..\..\..\components\libc\compilers\common\extension;..\libraries\HAL_Drivers;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;board\CubeMX_Config\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: rn8306.c main.c ht7132.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial_v2.c
    ../../../components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    board/port/: ef_fal_port.c spi_flash_init.c
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_qspi.c drv_rtc.c drv_sdram.c drv_spi.c drv_usart_v2.c
  group EasyFlash
    packages/EasyFlash-v4.1.0/src/: ef_iap.c ef_env_legacy_wl.c ef_cmd.c ef_utils.c easyflash.c ef_env_legacy.c ef_log.c ef_env.c
  group EasyLogger
    packages/EasyLogger-v2.0.0/src/: elog_utils.c elog.c elog_buf.c elog_async.c
    packages/EasyLogger-v2.0.0/port/: elog_port.c
    packages/EasyLogger-v2.0.0/plugins/flash/: elog_flash_port.c elog_flash.c
  group Fal
    ../../../components/fal/src/: fal.c fal_partition.c fal_rtt.c fal_flash.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c signal.c thread.c timer.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_rtc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
    ../../../components/libc/posix/io/stdio/: stdio.c
  group rs485
    packages/rs485-latest/src/: rs485.c rs485_test.c rs485_sample_master.c rs485_sample_slave.c
